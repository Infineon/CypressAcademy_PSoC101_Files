# Keil uVision project Simon_Slave_Pioneer_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: Simon_Slave_Pioneer_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h EZI2C.c EZI2C.h EZI2C_PM.c EZI2C_BOOT.c EZI2C_PINS.h EZI2C_PVT.h EZI2C_EZI2C.c EZI2C_EZI2C_INT.c EZI2C_EZI2C.h EZI2C_EZI2C_PVT.h EZI2C_EZI2C_BOOT.c Button1.c Button1.h Button1_aliases.h Button2.c Button2.h Button2_aliases.h Button3.c Button3.h Button3_aliases.h Button4.c Button4.h Button4_aliases.h EZI2C_SCB_IRQ.c EZI2C_SCB_IRQ.h EZI2C_SCBCLK.c EZI2C_SCBCLK.h EZI2C_scl.c EZI2C_scl.h EZI2C_scl_aliases.h EZI2C_sda.c EZI2C_sda.h EZI2C_sda_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h LEDreg.c LEDreg.h LED3.c LED3.h LED3_aliases.h LED2.c LED2.h LED2_aliases.h LED1.c LED1.h LED1_aliases.h LED4.c LED4.h LED4_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c SpeedPin.c SpeedPin.h SpeedPin_aliases.h ADC_intClock.c ADC_intClock.h ADC_IRQ.c ADC_IRQ.h BUZZER.c BUZZER.h BUZZER_aliases.h Clock_1.c Clock_1.h PWM_Fail.c PWM_Fail.h PWM_Fail_PM.c LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h isr_fail.c isr_fail.h isr_sleep.c isr_sleep.h Cheat.c Cheat.h Cheat_aliases.h LED_AWAKE.c LED_AWAKE.h LED_AWAKE_aliases.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: Simon_Slave_Pioneer_PSoC4lib (library)
