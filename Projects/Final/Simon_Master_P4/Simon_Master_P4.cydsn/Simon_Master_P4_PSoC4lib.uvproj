# Keil uVision project Simon_Master_P4_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: Simon_Master_P4_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h EEPROM.c EEPROM.h LCD.c LCD.h LCD_PM.c I2C.c I2C.h I2C_I2C.h I2C_I2C_INT.c I2C_I2C.c I2C_I2C_BOOT.c I2C_I2C_MASTER.c I2C_PM.c I2C_BOOT.c I2C_PINS.h I2C_I2C_PVT.h I2C_PVT.h LED1.c LED1.h LED1_aliases.h LED2.c LED2.h LED2_aliases.h LED3.c LED3.h LED3_aliases.h LED4.c LED4.h LED4_aliases.h Start.c Start.h Start_aliases.h LEDreg.c LEDreg.h ResetHS.c ResetHS.h ResetHS_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h I2C_SCB_IRQ.c I2C_SCB_IRQ.h I2C_SCBCLK.c I2C_SCBCLK.h I2C_scl.c I2C_scl.h I2C_scl_aliases.h I2C_sda.c I2C_sda.h I2C_sda_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h Max.c Max.h Max_aliases.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: Simon_Master_P4_PSoC4lib (library)
